options:
  parameters:
    generate_options: qt_gui
    id: manual_tempest_example
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: DelaySyncDetector
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_m@1
    orient: Qt.Horizontal
    start: '0'
    step: interpolatedHsize*1
    stop: Vsize*interpolatedHsize
    value: '0'
  states: {state: disabled}
- name: DroppedFrames
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_m@1
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: Hblank
  id: variable
  parameters:
    value: Hsize-Hvisible
  states: {}
- name: Hsize
  id: variable_qtgui_range
  parameters:
    label: Horizontal resolution (total)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(4096*1.5)
    value: '2200'
    widget: counter
  states: {}
- name: Hvisible
  id: variable
  parameters:
    value: '1920'
  states: {}
- name: Vblank
  id: variable
  parameters:
    value: Vsize-Vvisible
  states: {}
- name: Vsize
  id: variable_qtgui_range
  parameters:
    label: Vertical resolution (total)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(2160*1.5)
    value: '1125'
    widget: counter
  states: {}
- name: Vvisible
  id: variable
  parameters:
    value: '1080'
  states: {}
- name: angle_error
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_m@1
    label: Sine angle correction
    orient: Qt.Horizontal
    start: '-pi-0.2'
    step: '0.00001'
    stop: pi+0.2
    value: '-2.6'
    widget: counter
  states: {}
- name: denominador
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.91'
    step: '0.000001'
    stop: '1.1'
    value: '1.0'
  states: {}
- name: ferror
  id: variable
  parameters:
    value: (samp_rate*angle_error)/(2*pi*interpolatedHsize)
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: 2**21
  states: {}
- name: filtro_ecualizador_1st
  id: variable
  parameters:
    value: |-
      [-6.13e-05-1.22e-05j,
      6.18e-04-2.02e-04j,
      3.84e-03-2.43e-03j,
      5.50e-03-3.87e-03j,
      7.65e-03-5.51e-03j,
      8.36e-03-6.47e-03j,
      3.42e-03-3.78e-03j,
      -7.81e-03+2.35e-03j,
      -3.86e-02+2.21e-02j,
      -8.12e-02+4.68e-02j,
      -1.62e-01+9.94e-02j,
      -2.48e-01+1.48e-01j,
      -3.92e-01+2.43e-01j,
      -5.04e-01+2.99e-01j,
      -7.22e-01+4.49e-01j,
      -6.65e-01+3.56e-01j,
      7.83e-01-4.68e-01j,
      6.76e-01-3.60e-01j,
      5.19e-01-2.92e-01j,
      3.70e-01-1.98e-01j,
      2.48e-01-1.39e-01j,
      1.48e-01-8.02e-02j,
      7.74e-02-4.50e-02j,
      3.09e-02-1.83e-02j,
      4.68e-03-4.89e-03j,
      -6.43e-03+1.92e-03j,
      -9.85e-03+4.10e-03j,
      -8.23e-03+3.73e-03j,
      -5.86e-03+2.73e-03j,
      -3.57e-03+1.94e-03j,
      -1.81e-04+2.41e-04j,
      ]
  states: {}
- name: harmonic
  id: variable_qtgui_range
  parameters:
    label: Harmonic
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '10'
    value: '2'
  states: {}
- name: interpolatedHblank
  id: variable
  parameters:
    value: int(Hblank/float(px_rate)*samp_rate)
  states: {}
- name: interpolatedHscreen
  id: variable
  parameters:
    value: int(Hvisible/float(px_rate)*samp_rate)
  states: {}
- name: interpolatedHsize
  id: variable
  parameters:
    value: int(Hsize/float(px_rate)*samp_rate)
  states: {}
- name: inverted
  id: variable_qtgui_chooser
  parameters:
    label: Inverted colors?
    label0: 'Yes'
    label1: 'No'
    num_opts: '2'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: real
    value: '-1'
    widget: radio_buttons
  states: {}
- name: px_rate
  id: variable
  parameters:
    value: Hsize*Vsize*refresh_rate
  states: {}
- name: refresh_rate
  id: variable_qtgui_range
  parameters:
    label: Refresh Rate (Hz)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '240'
    value: '60'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: round(50e6)
  states: {}
- name: FFT_autocorrelation_0_0
  id: FFT_autocorrelation
  parameters:
    alpha: '0.5'
    fft_size: int(fft_size)
  states: {state: disabled}
- name: Keep_1_in_N_Frames_0
  id: Keep_1_in_N_Frames
  parameters:
    fac_decimation: DroppedFrames
    fft_size: int(fft_size)
  states: {state: disabled}
- name: Keep_1_in_N_Frames_0_0
  id: Keep_1_in_N_Frames
  parameters:
    fac_decimation: DroppedFrames
    fft_size: int(interpolatedHsize*Vsize*4)
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*pi/(samp_rate)
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-ferror'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: DelaySyncDetector
    type: complex
  states: {state: disabled}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: interpolatedHsize
    type: complex
  states: {state: disabled}
- name: blocks_delay_1_0
  id: blocks_delay
  parameters:
    delay: interpolatedHsize
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/felipe/gnuradio/git/grabaciones_local/DEMO_VGA_recording_1080p_60Hz_50MHz.dat
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/felipe/gnuradio/git/grabaciones_local/DEMO_VGA_recording_1080p_60Hz_50MHz.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: inverted
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: tab_m@0
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.5'
    ylabel: Phase difference (rad).
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab_m@1
    size: int(fft_size*2)
    srate: samp_rate
    tr_level: '18.0'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"peak_1"'
    type: float
    update_time: '1.0'
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00001'
    type: complex
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00001'
    type: complex
  states: {state: disabled}
- name: tab_m
  id: qtgui_tab_widget
  parameters:
    label0: Tempest Main Tab
    label1: Autocorrelation Plot Tab
    num_tabs: '2'
  states: {}
- name: tempest_fft_peak_fine_sampling_sync_0_0
  id: tempest_fft_peak_fine_sampling_sync
  parameters:
    Hvisible: interpolatedHsize
    Vvisible: Vsize
    automatic_mode: 'True'
    refresh_rate: refresh_rate
    sample_rate: int(samp_rate)
    size: int(fft_size)
  states: {state: disabled}
- name: tempest_fine_sampling_synchronization_0
  id: tempest_fine_sampling_synchronization
  parameters:
    Htotal: interpolatedHsize
    Vtotal: Vsize
    correct_sampling: '1'
    max_deviation: '10'
    update_proba: '1e-3'
  states: {state: disabled}
- name: tempest_normalize_flow_0
  id: tempest_normalize_flow
  parameters:
    alpha_avg: '1e-2'
    max: '245'
    min: '10'
    update_proba: '0.1'
    window: interpolatedHsize
  states: {state: disabled}
- name: tempest_ssamp_correction_0
  id: tempest_ssamp_correction
  parameters:
    Htotal: interpolatedHsize
    Vtotal: Vsize
    correct_sampling: '1'
    max_deviation: '10'
  states: {}
- name: tempest_sync_detector_0
  id: tempest_sync_detector
  parameters:
    hblanking: interpolatedHblank
    hscreen: interpolatedHscreen
    vblanking: Vblank
    vscreen: Vsize-Vblank
  states: {state: disabled}
- name: tempest_tempest_msgbtn_0
  id: tempest_tempest_msgbtn
  parameters:
    gui_hint: tab_m@1
    label: 'Ratio Finder toggle ON or OFF (FFT peaks). '
    msgName: pressed
    relBackgroundColor: default
    relFontColor: default
    type: bool
    value: 'True'
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: 10*px_rate*harmonic
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '"recv_frame_size= 65536, num_recv_frames=128"'
    gain0: '50'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: variable_qtgui_msg_push_button_0
  id: variable_qtgui_msg_push_button
  parameters:
    label: hh
    msgName: pressed
    type: bool
    value: 'True'
  states: {state: disabled}
- name: video_sdl_sink_0_0_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Enable this path when you are sure what the 
      resolution is (and defaut to those values on 
      the chooser).
    display_height: '517'
    display_width: '1088'
    fps: '0'
    height: Vsize
    type: short
    width: interpolatedHsize
  states: {state: disabled}

connections:
- [FFT_autocorrelation_0_0, '0', tempest_fft_peak_fine_sampling_sync_0_0, '0']
- [Keep_1_in_N_Frames_0, '0', FFT_autocorrelation_0_0, '0']
- [Keep_1_in_N_Frames_0, '0', blocks_delay_1, '0']
- [Keep_1_in_N_Frames_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [Keep_1_in_N_Frames_0_0, '0', FFT_autocorrelation_0_0, '0']
- [Keep_1_in_N_Frames_0_0, '0', blocks_complex_to_mag_0, '0']
- [Keep_1_in_N_Frames_0_0, '0', blocks_delay_1, '0']
- [Keep_1_in_N_Frames_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [Keep_1_in_N_Frames_0_0, '0', tempest_fine_sampling_synchronization_0, '0']
- [Keep_1_in_N_Frames_0_0, '0', tempest_ssamp_correction_0, '0']
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_complex_to_arg_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_complex_to_arg_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', tempest_normalize_flow_0, '0']
- [blocks_complex_to_real_0, '0', tempest_normalize_flow_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_delay_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_delay_1_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [blocks_file_source_0, '0', blocks_file_sink_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_short_0, '0', video_sdl_sink_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_delay_1_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_throttle_0, '0', Keep_1_in_N_Frames_0, '0']
- [blocks_throttle_0, '0', Keep_1_in_N_Frames_0_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_complex_to_arg_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', blocks_complex_to_arg_0_0, '0']
- [tempest_fft_peak_fine_sampling_sync_0_0, '0', qtgui_time_sink_x_1, '0']
- [tempest_fft_peak_fine_sampling_sync_0_0, en, FFT_autocorrelation_0_0, en]
- [tempest_fft_peak_fine_sampling_sync_0_0, en, tempest_fine_sampling_synchronization_0, en]
- [tempest_fft_peak_fine_sampling_sync_0_0, en, tempest_ssamp_correction_0, en]
- [tempest_fft_peak_fine_sampling_sync_0_0, en, tempest_sync_detector_0, en]
- [tempest_fft_peak_fine_sampling_sync_0_0, rate, uhd_usrp_source_0, command]
- [tempest_fft_peak_fine_sampling_sync_0_0, ratio, tempest_fine_sampling_synchronization_0, ratio]
- [tempest_fine_sampling_synchronization_0, '0', tempest_sync_detector_0, '0']
- [tempest_normalize_flow_0, '0', blocks_float_to_short_0, '0']
- [tempest_ssamp_correction_0, '0', blocks_null_sink_0, '0']
- [tempest_sync_detector_0, '0', blocks_complex_to_mag_0, '0']
- [tempest_sync_detector_0, '0', blocks_delay_0, '0']
- [tempest_sync_detector_0, '0', blocks_multiply_xx_0_0_0, '1']
- [tempest_tempest_msgbtn_0, pressed, tempest_fft_peak_fine_sampling_sync_0_0, en]
- [uhd_usrp_source_0, '0', Keep_1_in_N_Frames_0, '0']
- [uhd_usrp_source_0, '0', Keep_1_in_N_Frames_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [variable_qtgui_msg_push_button_0, pressed, tempest_fft_peak_fine_sampling_sync_0_0, en]

metadata:
  file_format: 1
