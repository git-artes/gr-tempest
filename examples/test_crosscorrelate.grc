options:
  parameters:
    generate_options: qt_gui
    id: autocorrelator_max
    output_language: python
  states: {}

blocks:
- name: delay_0
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '20'
    step: '1'
    stop: fft_size
    value: '20'
  states: {}
- name: delay_samples_var
  id: variable
  parameters:
    value: delay_0
  states: {}
- name: fac_size
  id: variable
  parameters:
    value: fft_size
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: round(1344*806/2)
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2441e6
  states: {}
- name: klog
  id: variable
  parameters:
    value: '-20*log10(fac_size)'
  states: {}
- name: max_index_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ruido
  id: variable
  parameters:
    value: np.random.rand(1344*806-1000)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: FFT_autocorrelation_0
  id: FFT_autocorrelation
  parameters:
    fac_decimation: '10'
    fft_size: int(fft_size)
    sample_rate: int(samp_rate)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '120'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '120'
    offset: '350'
    phase: 3.14/2
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SAW_WAVE
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fac_size
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fac_size
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: fac_decimation
    type: complex
    vlen: fac_size
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: fac_decimation
    type: complex
    vlen: fac_size
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: fac_size
  states: {}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    k: klog
    n: '20'
    vlen: fac_size
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fac_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fac_size
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[0]*1000+list(ruido)'
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: list(ruido)+[0]*1000
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: fac_decimation
  id: parameter
  parameters:
    label: fac_decimation
    type: intx
    value: '10'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fac_size
    forward: 'True'
    nthreads: '4'
    shift: 'False'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fac_size
    forward: 'True'
    nthreads: '4'
    shift: 'False'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fac_size
    forward: 'False'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import log10
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: int(fft/2)
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: auto
    label2: cross
    nconnections: '2'
    size: int(fft_size)
    srate: int(50e6)
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1.0'
    type: float
    vlen: fac_size
  states: {}
- name: tempest_frame_drop_0
  id: tempest_frame_drop
  parameters:
    Htotal: '1000'
    Vtotal: '2'
    actual_samp_rate: samp_rate
    correct_sampling: '1'
    max_deviation: '10'
    update_proba: '0.01'
  states: {state: disabled}

connections:
- [FFT_autocorrelation_0, '0', qtgui_time_sink_x_0, '1']
- [FFT_autocorrelation_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_complex_to_mag_0_0, '0', fft_vxx_1, '0']
- [blocks_complex_to_mag_0_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_complex_to_mag_0_0_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_keep_one_in_n_0, '0', fft_vxx_0, '0']
- [blocks_keep_one_in_n_0_0, '0', fft_vxx_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_1, '0']
- [blocks_nlog10_ff_1, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_throttle_0, '0', FFT_autocorrelation_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle_0_0, '0', blocks_delay_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_throttle_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0_0, '1']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_1, '0', blocks_complex_to_mag_0_0_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_nlog10_ff_1, '0']

metadata:
  file_format: 1
