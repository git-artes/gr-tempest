options:
  parameters:
    generate_options: qt_gui
    id: manual_tempest_hdmi_example
    output_language: python
  states: {}

blocks:
- name: Hdisplay
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Hsize
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1,1
    label: Horizontal resolution (total)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(4096*1.5)
    value: '1328'
    widget: counter
  states: {}
- name: Vdisplay
  id: variable
  parameters:
    value: '768'
  states: {}
- name: Vsize
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 1, 1,1
    label: Vertical resolution (total)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(2160*1.5)
    value: '806'
    widget: counter
  states: {}
- name: epsilon
  id: variable_qtgui_range
  parameters:
    gui_hint: 4, 0, 1,2
    label: Fine sampling correction
    orient: Qt.Horizontal
    start: (interpolatedHsize-1)/float(interpolatedHsize)-1
    step: '1e-7'
    stop: (interpolatedHsize+1)/float(interpolatedHsize)-1
    value: '0'
  states: {}
- name: harmonic
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,1,1,1
    label: Harmonic
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: horizontal_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 3, 0, 1,2
    label: Horizontal offset
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: interpolatedHsize
    value: '0'
  states: {}
- name: interpolatedHsize
  id: variable
  parameters:
    value: int(Hsize/float(px_rate)*samp_rate)
  states: {}
- name: inverted
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 6,0,1,2
    label: Inverted Color?
    label0: 'No'
    label1: 'Yes'
    num_opts: '2'
    option1: '-1'
    orient: Qt.QHBoxLayout
    type: real
    value: '1'
    widget: radio_buttons
  states: {}
- name: lines_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0, 1,2
    label: Vertical offset
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Vsize
    value: int(Vsize/2)
  states: {}
- name: px_rate
  id: variable
  parameters:
    value: Hsize*Vsize*refresh_rate
  states: {}
- name: refresh_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,0,1,1
    label: Refresh Rate (Hz)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '240'
    value: '70'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(40e6)
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: interpolatedHsize*lines_offset+horizontal_offset
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/gnuradio/persistent/grabacion_HDMI.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: inverted
  states: {state: disabled}
- name: blocks_float_to_short_0_0_0
  id: blocks_float_to_short
  parameters:
    scale: inverted
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: tempest_framing_0
  id: tempest_framing
  parameters:
    Hdisplay: Hdisplay
    Htotal: interpolatedHsize
    Vdisplay: Vdisplay
    Vtotal: Vsize
  states: {state: disabled}
- name: tempest_normalize_flow_0
  id: tempest_normalize_flow
  parameters:
    alpha_avg: '1e-2'
    max: '245'
    min: '10'
    update_proba: '0.1'
    window: interpolatedHsize
  states: {}
- name: tempest_sampling_synchronization_0
  id: tempest_sampling_synchronization
  parameters:
    Htotal: interpolatedHsize
    manual_correction: epsilon
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: px_rate*harmonic*10
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '50'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: video_sdl_sink_0_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Enable this path when you are not sure what the 
      resolution is and you want to try several ones 
      on run-time. Then, enable the other path.
    display_height: Vdisplay
    display_width: Hdisplay
    fps: '0'
    height: Vdisplay
    type: short
    width: Hdisplay
  states: {state: disabled}
- name: video_sdl_sink_0_0_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Enable this path when you are sure what the 
      resolution is (and defaut to those values on 
      the chooser).
    display_height: Vsize
    display_width: Hsize
    fps: '0'
    height: Vsize
    type: short
    width: interpolatedHsize
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', tempest_normalize_flow_0, '0']
- [blocks_delay_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_short_0_0, '0', video_sdl_sink_0_0, '0']
- [blocks_float_to_short_0_0_0, '0', video_sdl_sink_0_0_0, '0']
- [blocks_throttle_0, '0', tempest_sampling_synchronization_0, '0']
- [tempest_framing_0, '0', blocks_float_to_short_0_0, '0']
- [tempest_normalize_flow_0, '0', blocks_float_to_short_0_0_0, '0']
- [tempest_normalize_flow_0, '0', tempest_framing_0, '0']
- [tempest_sampling_synchronization_0, '0', blocks_delay_0, '0']
- [uhd_usrp_source_0, '0', tempest_sampling_synchronization_0, '0']

metadata:
  file_format: 1
