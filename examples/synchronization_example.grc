<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Hblank</value></param>
<param><key>value</key><value>Hsize-Hutil</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Hsize</value></param>
<param><key>value</key><value>1344</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Hutil</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Vblank</value></param>
<param><key>value</key><value>Vsize-Vutil</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Vsize</value></param>
<param><key>value</key><value>806</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Vutil</value></param>
<param><key>value</key><value>768</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>inter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>136</value></param>
<param><key>label</key><value>delay</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>2*Hblank</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>epsilon</value></param>
<param><key>value</key><value>0.99950</value></param>
<param><key>label</key><value>epsilon</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.9</value></param>
<param><key>step</key><value>10e-6</value></param>
<param><key>stop</key><value>1.1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>escalar</value></param>
<param><key>value</key><value>550</value></param>
<param><key>label</key><value>escalar normalizador</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-2550</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>2550</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>frec</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>error_frec</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1</value></param>
<param><key>step</key><value>1e-5</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>inter</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>5</value></param>
<param><key>label</key><value>offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-2550</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>2550</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulso_rectangular</value></param>
<param><key>value</key><value>[1.12,0.98458,1,1.0001,0.99994,1,1,1,1,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>px_rate</value></param>
<param><key>value</key><value>Hsize*Vsize*refresh_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>refresh_rate</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ruido</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>ruido</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>30e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_rate</value></param>
<param><key>value</key><value>int(30e6)</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_1</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>delay</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>30M_tv_g50_v2.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>escalar</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>comment</key><value>lo paso por el canal</value></param>
<param><key>epsilon</key><value>epsilon</value></param>
<param><key>freq_offset</key><value>frec/samp_rate</value></param>
<param><key>noise_voltage</key><value>ruido</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio.filter import firdes</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"correlacion"</value></param>
<param><key>size</key><value>Hsize*1</value></param>
<param><key>srate</key><value>usrp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024*624*3</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>255</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_2_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"magnitud salida canal"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>Hsize*1</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>comment</key><value>le ajusto algunos parametros a mano</value></param>
<param><key>decim</key><value>usrp_rate</value></param>
<param><key>interp</key><value>px_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>tempest_Hsync</key>
<param><key>id</key><value>tempest_Hsync_0</value></param>
<param><key>delay</key><value>136</value></param>
<param><key>Htotal</key><value>Hsize</value></param>
</block>
<block>
<key>tempest_sampling_synchronization</key>
<param><key>id</key><value>tempest_sampling_synchronization_0</value></param>
<param><key>Htotal</key><value>Hsize</value></param>
</block>
<block>
<key>video_sdl_sink</key>
<param><key>id</key><value>video_sdl_sink_0</value></param>
<param><key>display_height</key><value>Vsize</value></param>
<param><key>display_width</key><value>Hsize</value></param>
<param><key>fps</key><value>0</value></param>
<param><key>height</key><value>Vsize</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>width</key><value>Hsize</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_2_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>video_sdl_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>tempest_sampling_synchronization_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tempest_Hsync_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tempest_sampling_synchronization_0</source_block_id><sink_block_id>tempest_Hsync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
