options:
  parameters:
    author: tempest
    category: '[Tempest]'
    generate_options: hb
    id: FFT_autocorrelation
    output_language: python
    title: FFT_autocorrelation_
  states: {}

blocks:
- name: fac_size
  id: variable
  parameters:
    value: fft_size
  states: {}
- name: klog
  id: variable
  parameters:
    value: '-20*log10(fac_size)'
  states: {}
- name: alpha
  id: parameter
  parameters:
    value: '1.0'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fac_size
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fac_size
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: fac_decimation
    type: complex
    vlen: fac_size
  states: {}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    k: klog
    n: '20'
    vlen: fac_size
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fac_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: fac_decimation
  id: parameter
  parameters:
    label: fac_decimation
    type: intx
    value: '10'
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: fft_size
    type: intx
    value: int(4096*512)
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fac_size
    forward: 'True'
    nthreads: '4'
    shift: 'False'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fac_size
    forward: 'False'
    nthreads: '4'
    shift: 'True'
    type: float
    window: ()
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import log10
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: en
    optional: 'True'
    type: message
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    label: sample_rate
    type: intx
    value: int(50e6)
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: alpha
    type: float
    vlen: fac_size
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', fft_vxx_1, '0']
- [blocks_complex_to_mag_0_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', fft_vxx_0, '0']
- [blocks_nlog10_ff_1, '0', blocks_vector_to_stream_0, '0']
- [blocks_selector_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_vector_to_stream_0, '0', pad_sink_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [fft_vxx_1, '0', blocks_complex_to_mag_0_0, '0']
- [pad_source_0, '0', blocks_selector_0, '0']
- [pad_source_0_0, out, blocks_selector_0, en]
- [single_pole_iir_filter_xx_0, '0', blocks_nlog10_ff_1, '0']

metadata:
  file_format: 1
