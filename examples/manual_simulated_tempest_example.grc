options:
  parameters:
    generate_options: qt_gui
    id: manual_simulated_tempest_example
    output_language: python
  states: {}

blocks:
- name: Hdisplay
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Hsize
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1,1
    label: Horizontal resolution (total)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(4096*1.5)
    value: '1024'
    widget: counter
  states: {}
- name: Hvisible
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1,1
    label: Horizontal resolution (visible)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(4096*1.5)
    value: '800'
    widget: counter
  states: {}
- name: Vdisplay
  id: variable
  parameters:
    value: '768'
  states: {}
- name: Vsize
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 1, 1,1
    label: Vertical resolution (total)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(2160*1.5)
    value: '624'
    widget: counter
  states: {}
- name: Vvisible
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 1, 1,1
    label: Vertical resolution (visible)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(2160*1.5)
    value: '600'
    widget: counter
  states: {}
- name: decim
  id: variable
  parameters:
    value: inter
  states: {}
- name: epsilon
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,0,1,2
    label: Fine sampling correction
    orient: Qt.Horizontal
    start: (interpolatedHsize-1)/float(interpolatedHsize)-1
    step: '1e-7'
    stop: (interpolatedHsize+1)/float(interpolatedHsize)-1
    value: '0'
  states: {}
- name: epsilon_channel
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Sampling error
    orient: Qt.Horizontal
    start: '0.9'
    step: '10e-6'
    stop: '1.1'
    value: '1'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Frequency Error (normalized)
    orient: Qt.Horizontal
    start: '-1'
    step: '1e-5'
    stop: '1'
    value: '0'
  states: {}
- name: harmonic
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: Harmonic
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: horizontal_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,2
    label: Horizontal offset
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: interpolatedHsize
    value: '0'
  states: {}
- name: inter
  id: variable
  parameters:
    value: '10'
  states: {}
- name: interpolatedHsize
  id: variable
  parameters:
    value: int(Hsize/float(px_rate)*usrp_rate)
  states: {}
- name: inverted
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 8,1,1,1
    label: Inverted Color?
    label0: 'Yes'
    label1: 'No'
    num_opts: '2'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: real
    value: '-1'
    widget: radio_buttons
  states: {}
- name: lines_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,2
    label: Vertical offset
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Vsize
    value: int(Vsize/2)
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Noise Power
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '10'
    value: '1.5'
  states: {}
- name: pulso_rectangular
  id: variable
  parameters:
    value: '[1]*inter'
  states: {}
- name: px_rate
  id: variable
  parameters:
    value: Hsize*Vsize*refresh_rate
  states: {}
- name: refresh_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,0,1,1
    label: Refresh Rate (Hz)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '240'
    value: '60'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: px_rate*inter
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: int(30e6)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: px_rate*harmonic
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: interpolatedHsize*lines_offset+horizontal_offset
    type: complex
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: inverted
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: inverted
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: epsilon_channel
    freq_offset: freq
    noise_voltage: noise
    seed: '0'
    taps: '1'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: genero la forma de onda en el cable
    interp: inter
    taps: pulso_rectangular
    type: fcc
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: usrp_rate
    taps: ''
    type: ccc
  states: {}
- name: tempest_framing_0
  id: tempest_framing
  parameters:
    Hdisplay: Hdisplay
    Htotal: interpolatedHsize
    Vdisplay: Vdisplay
    Vtotal: Vsize
  states: {}
- name: tempest_image_source_0
  id: tempest_image_source
  parameters:
    Htotal: '1024'
    Hvisible: '800'
    Vtotal: '624'
    Vvisible: '600'
    image_file: /home/gnuradio/persistent/gr-tempest/Imagen_800_600.png
    repeatmode: '1'
  states: {}
- name: tempest_normalize_flow_0
  id: tempest_normalize_flow
  parameters:
    alpha_avg: '1e-2'
    max: '245'
    min: '10'
    update_proba: '0.1'
    window: interpolatedHsize
  states: {}
- name: tempest_sampling_synchronization_0
  id: tempest_sampling_synchronization
  parameters:
    Htotal: interpolatedHsize
    manual_correction: epsilon
  states: {}
- name: video_sdl_sink_0_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Enable this path when you are not sure what the 
      resolution is and you want to try several ones 
      on run-time. Then, enable the other path.
    display_height: Vdisplay
    display_width: Hdisplay
    fps: '0'
    height: Vdisplay
    type: short
    width: Hdisplay
  states: {}
- name: video_sdl_sink_0_0_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Enable this path when you are sure what the 
      resolution is (and defaut to those values on 
      the chooser).
    display_height: Vsize
    display_width: Hsize
    fps: '0'
    height: Vsize
    type: short
    width: interpolatedHsize
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_mag_0, '0', tempest_normalize_flow_0, '0']
- [blocks_delay_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_float_to_short_0, '0', video_sdl_sink_0_0, '0']
- [blocks_float_to_short_0_0, '0', video_sdl_sink_0_0_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_0_0, '0', blocks_multiply_xx_0, '0']
- [channels_channel_model_0, '0', tempest_sampling_synchronization_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle_0_0, '0']
- [rational_resampler_xxx_0, '0', channels_channel_model_0, '0']
- [tempest_framing_0, '0', blocks_float_to_short_0, '0']
- [tempest_image_source_0, '0', interp_fir_filter_xxx_0, '0']
- [tempest_normalize_flow_0, '0', blocks_float_to_short_0_0, '0']
- [tempest_normalize_flow_0, '0', tempest_framing_0, '0']
- [tempest_sampling_synchronization_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
