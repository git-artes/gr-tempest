<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>manual_tempest_example</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Hdisplay</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Hsize</value></param>
<param><key>value</key><value>1024</value></param>
<param><key>gui_hint</key><value>1, 0, 1,1</value></param>
<param><key>label</key><value>Horizontal resolution (total)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>int(4096*1.5)</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Hvisible</value></param>
<param><key>value</key><value>800</value></param>
<param><key>gui_hint</key><value>0, 0, 1,1</value></param>
<param><key>label</key><value>Horizontal resolution (visible)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>int(4096*1.5)</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Vdisplay</value></param>
<param><key>value</key><value>768</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Vsize</value></param>
<param><key>value</key><value>624</value></param>
<param><key>gui_hint</key><value>1, 1, 1,1</value></param>
<param><key>label</key><value>Vertical resolution (total)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>int(2160*1.5)</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Vvisible</value></param>
<param><key>value</key><value>600</value></param>
<param><key>gui_hint</key><value>0, 1, 1,1</value></param>
<param><key>label</key><value>Vertical resolution (visible)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>int(2160*1.5)</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>inter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>epsilon</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Fine sampling correction</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>(interpolatedHsize-1)/float(interpolatedHsize)-1</value></param>
<param><key>step</key><value>1e-7</value></param>
<param><key>stop</key><value>(interpolatedHsize+1)/float(interpolatedHsize)-1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>epsilon_channel</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label</key><value>Sampling error</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.9</value></param>
<param><key>step</key><value>10e-6</value></param>
<param><key>stop</key><value>1.1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>Frequency Error (normalized)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1</value></param>
<param><key>step</key><value>1e-5</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>harmonic</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label</key><value>Harmonic</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>horizontal_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Horizontal offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>interpolatedHsize</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>inter</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interpolatedHsize</value></param>
<param><key>value</key><value>int(Hsize/float(px_rate)*usrp_rate)</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>inverted</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label0</key><value>Yes</value></param>
<param><key>label1</key><value>No</value></param>
<param><key>label</key><value>Inverted colors?</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>-1</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lines_offset</value></param>
<param><key>value</key><value>Vsize/2</value></param>
<param><key>label</key><value>Vertical offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>Vsize</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>1.5</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>label</key><value>Noise Power</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulso_rectangular</value></param>
<param><key>value</key><value>[1]*inter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>px_rate</value></param>
<param><key>value</key><value>Hsize*Vsize*refresh_rate</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>refresh_rate</value></param>
<param><key>value</key><value>60</value></param>
<param><key>label</key><value>Refresh Rate (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>240</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>px_rate*inter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_rate</value></param>
<param><key>value</key><value>int(30e6)</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>px_rate*harmonic</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>interpolatedHsize*lines_offset+horizontal_offset</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0</value></param>
<param><key>scale</key><value>inverted</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>inverted</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>epsilon_channel</value></param>
<param><key>freq_offset</key><value>freq</value></param>
<param><key>noise_voltage</key><value>noise</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>comment</key><value>genero la forma de onda en el cable</value></param>
<param><key>interp</key><value>inter</value></param>
<param><key>taps</key><value>pulso_rectangular</value></param>
<param><key>type</key><value>fcc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>samp_rate</value></param>
<param><key>interp</key><value>usrp_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>tempest_framing</key>
<param><key>id</key><value>tempest_framing_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>Hdisplay</key><value>Hdisplay</value></param>
<param><key>Htotal</key><value>interpolatedHsize</value></param>
<param><key>Vdisplay</key><value>Vdisplay</value></param>
<param><key>Vtotal</key><value>Vsize</value></param>
</block>
<block>
<key>tempest_image_source</key>
<param><key>id</key><value>tempest_image_source_0</value></param>
<param><key>Htotal</key><value>1024</value></param>
<param><key>Hvisible</key><value>800</value></param>
<param><key>image_file</key><value>Imagen_800_600.png</value></param>
<param><key>repeatmode</key><value>1</value></param>
<param><key>Vtotal</key><value>624</value></param>
<param><key>Vvisible</key><value>600</value></param>
</block>
<block>
<key>tempest_normalize_flow</key>
<param><key>id</key><value>tempest_normalize_flow_0</value></param>
<param><key>alpha_avg</key><value>1e-2</value></param>
<param><key>max</key><value>245</value></param>
<param><key>min</key><value>10</value></param>
<param><key>update_proba</key><value>0.1</value></param>
<param><key>window</key><value>interpolatedHsize</value></param>
</block>
<block>
<key>tempest_sampling_synchronization</key>
<param><key>id</key><value>tempest_sampling_synchronization_0</value></param>
<param><key>Htotal</key><value>interpolatedHsize</value></param>
<param><key>manual_correction</key><value>epsilon</value></param>
</block>
<block>
<key>video_sdl_sink</key>
<param><key>id</key><value>video_sdl_sink_0_0</value></param>
<param><key>comment</key><value>Enable this path when you are not sure what the 
resolution is and you want to try several ones 
on run-time. Then, enable the other path.</value></param>
<param><key>display_height</key><value>Vdisplay</value></param>
<param><key>display_width</key><value>Hdisplay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fps</key><value>0</value></param>
<param><key>height</key><value>Vdisplay</value></param>
<param><key>type</key><value>short</value></param>
<param><key>width</key><value>Hdisplay</value></param>
</block>
<block>
<key>video_sdl_sink</key>
<param><key>id</key><value>video_sdl_sink_0_0_0</value></param>
<param><key>comment</key><value>Enable this path when you are sure what the 
resolution is (and defaut to those values on 
the chooser).</value></param>
<param><key>display_height</key><value>Vsize</value></param>
<param><key>display_width</key><value>Hsize</value></param>
<param><key>fps</key><value>0</value></param>
<param><key>height</key><value>Vsize</value></param>
<param><key>type</key><value>short</value></param>
<param><key>width</key><value>interpolatedHsize</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>tempest_normalize_flow_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0</source_block_id><sink_block_id>video_sdl_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0_0</source_block_id><sink_block_id>video_sdl_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>tempest_sampling_synchronization_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tempest_framing_0</source_block_id><sink_block_id>blocks_float_to_short_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tempest_image_source_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tempest_normalize_flow_0</source_block_id><sink_block_id>blocks_float_to_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tempest_normalize_flow_0</source_block_id><sink_block_id>tempest_framing_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tempest_sampling_synchronization_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
