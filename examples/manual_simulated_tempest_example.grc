options:
  parameters:
    generate_options: qt_gui
    id: manual_simulated_tempest_example
    output_language: python
  states: {}

blocks:
- name: Hblank
  id: variable
  parameters:
    value: Hsize-Hvisible
  states: {}
- name: Hdisplay
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Hsize
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Hvisible
  id: variable
  parameters:
    value: '800'
  states: {}
- name: Vblank
  id: variable
  parameters:
    value: Vsize-Vvisible
  states: {}
- name: Vdisplay
  id: variable
  parameters:
    value: '768'
  states: {}
- name: Vsize
  id: variable
  parameters:
    value: '624'
  states: {}
- name: Vvisible
  id: variable
  parameters:
    value: '600'
  states: {}
- name: decim
  id: variable
  parameters:
    value: inter
  states: {}
- name: delayrange
  id: variable_qtgui_range
  parameters:
    label: delay
    orient: Qt.Horizontal
    start: '0'
    step: interpolatedHsize
    stop: interpolatedHsize*Vsize
    value: interpolatedHsize*63
  states: {}
- name: epsilon_channel
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Sampling error
    orient: Qt.Horizontal
    start: '-0.1'
    step: '10e-6'
    stop: '0.1'
    value: '0'
  states: {state: disabled}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency Error (normalized)
    orient: Qt.Horizontal
    start: '-1'
    step: '1e-5'
    stop: '1'
    value: '0'
  states: {state: disabled}
- name: harmonic
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Harmonic
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: horizontal_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Horizontal offset
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: interpolatedHsize
    value: '0'
  states: {state: disabled}
- name: inter
  id: variable
  parameters:
    value: '10'
  states: {}
- name: interpolatedHblank
  id: variable
  parameters:
    value: int(Hblank/float(px_rate)*usrp_rate)
  states: {}
- name: interpolatedHscreen
  id: variable
  parameters:
    value: int(Hvisible/float(px_rate)*usrp_rate)
  states: {}
- name: interpolatedHsize
  id: variable
  parameters:
    value: int(Hsize/float(px_rate)*usrp_rate)
  states: {}
- name: inverted
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,1,1,1
    label: Inverted colors?
    label0: 'Yes'
    label1: 'No'
    num_opts: '2'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: real
    value: '1'
    widget: radio_buttons
  states: {state: disabled}
- name: lines_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: Vertical offset
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Vsize
    value: int(Vsize/2)
  states: {state: disabled}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Noise Power
    orient: Qt.Horizontal
    start: '0'
    step: '1e-4'
    stop: '2e-2'
    value: '1e-3'
  states: {state: disabled}
- name: px_rate
  id: variable
  parameters:
    value: Hsize*Vsize*refresh_rate
  states: {}
- name: rectangular_pulse
  id: variable
  parameters:
    value: '[0.7/255]*inter'
  states: {}
- name: refresh_rate
  id: variable
  parameters:
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: px_rate*inter
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: int(30e6)
  states: {}
- name: FFT_autocorrelation_0
  id: FFT_autocorrelation
  parameters:
    fac_decimation: '10'
    fft_size: int(4096*512)
    sample_rate: int(50e6)
  states: {state: disabled}
- name: FFT_crosscorrelation_0
  id: FFT_crosscorrelation
  parameters:
    delay_samples: '8'
    fac_decimation: '10'
    fft_size: int(Hsize)
    sample_rate: int(50e6)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: px_rate*harmonic
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delayrange
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /media/felipe/BAYCHIP/gr-tempest/grabacion_splitter_40M_1344_806_px_freq_64995840.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: epsilon_channel+1
    freq_offset: freq
    noise_voltage: noise
    seed: '0'
    taps: '1'
  states: {state: disabled}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: genero la forma de onda en el cable
    interp: inter
    taps: rectangular_pulse
    type: fcc
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: int(Hsize)
    srate: int(50e6)
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: usrp_rate
    taps: ''
    type: ccc
  states: {state: disabled}
- name: tempest_fine_sampling_synchronization_0
  id: tempest_fine_sampling_synchronization
  parameters:
    Htotal: interpolatedHsize
    Vtotal: Vsize
    correct_sampling: '1'
    max_deviation: 100.0/interpolatedHsize
    update_proba: 1.0/(interpolatedHsize*Vsize)
  states: {state: disabled}
- name: tempest_frame_drop_0
  id: tempest_frame_drop
  parameters:
    Htotal: interpolatedHsize
    Vtotal: Vsize
    actual_samp_rate: samp_rate
    correct_sampling: '1'
    max_deviation: 100.0/interpolatedHsize
    update_proba: 1.0/(interpolatedHsize*Vsize)
  states: {}
- name: tempest_image_source_0
  id: tempest_image_source
  parameters:
    Htotal: '1024'
    Hvisible: '800'
    Vtotal: '624'
    Vvisible: '600'
    image_file: /home/felipe/gnuradio/git/fork-gr-tempest/gr-tempest/Imagen_800_600.png
    repeatmode: '1'
  states: {state: disabled}
- name: tempest_infer_resolution_0
  id: tempest_infer_resolution
  parameters:
    fft_size: ''
    samp_rate: ''
  states: {state: disabled}
- name: tempest_normalize_flow_0
  id: tempest_normalize_flow
  parameters:
    alpha_avg: '1e-2'
    max: '245'
    min: '10'
    update_proba: '0.1'
    window: interpolatedHsize
  states: {}
- name: tempest_sync_detector_0
  id: tempest_sync_detector
  parameters:
    hblanking: interpolatedHblank
    hscreen: interpolatedHscreen
    vblanking: Vblank
    vscreen: Vvisible
  states: {state: disabled}
- name: video_sdl_sink_0_0_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Enable this path when you are sure what the 
      resolution is (and defaut to those values on 
      the chooser).
    display_height: Vsize
    display_width: Hsize
    fps: '0'
    height: Vsize
    type: short
    width: interpolatedHsize
  states: {}

connections:
- [FFT_autocorrelation_0, '0', tempest_infer_resolution_0, '0']
- [FFT_crosscorrelation_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_mag_0, '0', tempest_normalize_flow_0, '0']
- [blocks_delay_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_short_0, '0', video_sdl_sink_0_0_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_0, '0', tempest_frame_drop_0, '0']
- [blocks_throttle_0_0, '0', blocks_multiply_xx_0, '0']
- [channels_channel_model_0, '0', FFT_autocorrelation_0, '0']
- [channels_channel_model_0, '0', tempest_frame_drop_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle_0_0, '0']
- [rational_resampler_xxx_0, '0', channels_channel_model_0, '0']
- [tempest_fine_sampling_synchronization_0, '0', tempest_sync_detector_0, '0']
- [tempest_frame_drop_0, '0', FFT_crosscorrelation_0, '0']
- [tempest_frame_drop_0, '0', blocks_complex_to_mag_0, '0']
- [tempest_frame_drop_0, '0', tempest_fine_sampling_synchronization_0, '0']
- [tempest_frame_drop_0, ratio, tempest_fine_sampling_synchronization_0, ratio]
- [tempest_image_source_0, '0', interp_fir_filter_xxx_0, '0']
- [tempest_infer_resolution_0, '0', blocks_null_sink_0, '0']
- [tempest_normalize_flow_0, '0', blocks_float_to_short_0, '0']
- [tempest_sync_detector_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
