options:
  parameters:
    generate_options: qt_gui
    id: manual_tempest_example
    output_language: python
  states: {}

blocks:
- name: Hdisplay
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Hsize
  id: variable_qtgui_range
  parameters:
    label: Horizontal resolution (total)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(4096*1.5)
    value: '1344'
    widget: counter
  states: {}
- name: Vdisplay
  id: variable
  parameters:
    value: '768'
  states: {}
- name: Vsize
  id: variable_qtgui_range
  parameters:
    label: Vertical resolution (total)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(2160*1.5)
    value: '806'
    widget: counter
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: |
      2**21
  states: {}
- name: harmonic
  id: variable_qtgui_range
  parameters:
    label: Harmonic
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '10'
    value: '5'
  states: {}
- name: horizontal_offset
  id: variable_qtgui_range
  parameters:
    label: Horizontal offset
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: interpolatedHsize
    value: '0'
  states: {}
- name: interpolatedHsize
  id: variable
  parameters:
    value: int(Hsize/float(px_rate)*samp_rate)
  states: {}
- name: lines_offset
  id: variable_qtgui_range
  parameters:
    label: Vertical offset
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Vsize
    value: int(Vsize/2)
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: 1024*2
    value: '50'
  states: {}
- name: offset___9
  id: variable
  parameters:
    value: '32'
  states: {}
- name: px_rate
  id: variable
  parameters:
    value: Hsize*Vsize*refresh_rate
  states: {}
- name: refresh_rate
  id: variable_qtgui_range
  parameters:
    label: Refresh Rate (Hz)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '240'
    value: '60'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(16.056e6)
  states: {}
- name: FFT_autocorrelation_0
  id: FFT_autocorrelation
  parameters:
    alpha: '1.0'
    fac_decimation: '10'
    fft_size: fft_size*64
    sample_rate: samp_rate
  states: {state: disabled}
- name: FFT_autocorrelation_0_0
  id: FFT_autocorrelation
  parameters:
    alpha: '1.0'
    fac_decimation: '10'
    fft_size: fft_size
    sample_rate: samp_rate
  states: {}
- name: FFT_crosscorrelation_0_0
  id: FFT_crosscorrelation
  parameters:
    delay_samples: '0'
    fac_decimation: '10'
    fft_size: fft_size
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: interpolatedHsize*lines_offset+horizontal_offset
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/pablo/fing/proyecto/grabaciones/test20210515
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /media/felipe/BAYCHIP/gr-tempest/data
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: 512*4
    srate: samp_rate
    tr_delay: '4'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"trigger"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: auto
    size: int(fft_size/4)
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"peak_1"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: auto
    size: int(fft_size/4)
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: tempest_fft_peak_fine_sampling_sync_0
  id: tempest_fft_peak_fine_sampling_sync
  parameters:
    Hvisible: interpolatedHsize
    Vvisible: Vsize
    automatic_mode: 'True'
    refresh_rate: refresh_rate
    sample_rate: samp_rate
    size: fft_size
  states: {}
- name: tempest_fine_sampling_synchronization_0
  id: tempest_fine_sampling_synchronization
  parameters:
    Htotal: interpolatedHsize
    Vtotal: Vsize
    correct_sampling: '1'
    max_deviation: '10'
    update_proba: '1e-3'
  states: {}
- name: tempest_infer_resolution_0
  id: tempest_infer_resolution
  parameters:
    Hvisible: ''
    Vsize: ''
    automatic_mode: ''
    refresh_rate: ''
    sample_rate: ''
    size: ''
  states: {state: disabled}
- name: tempest_message_to_var_0
  id: tempest_message_to_var
  parameters:
    target: samp_rate
  states: {state: disabled}
- name: tempest_normalize_flow_0
  id: tempest_normalize_flow
  parameters:
    alpha_avg: '1e-2'
    max: '245'
    min: '10'
    update_proba: '0.1'
    window: interpolatedHsize
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: px_rate*harmonic
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '40'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: video_sdl_sink_0_0_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Enable this path when you are sure what the 
      resolution is (and defaut to those values on 
      the chooser).
    display_height: Vsize
    display_width: Hsize
    fps: '0'
    height: Vsize
    type: short
    width: interpolatedHsize
  states: {}

connections:
- [FFT_autocorrelation_0, '0', qtgui_time_sink_x_0_0, '0']
- [FFT_autocorrelation_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [FFT_autocorrelation_0_0, '0', tempest_fft_peak_fine_sampling_sync_0, '0']
- [FFT_autocorrelation_0_0, '0', tempest_infer_resolution_0, '0']
- [FFT_crosscorrelation_0_0, '0', tempest_fft_peak_fine_sampling_sync_0, '0']
- [blocks_complex_to_mag_0, '0', tempest_normalize_flow_0, '0']
- [blocks_delay_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_short_0_0, '0', video_sdl_sink_0_0_0, '0']
- [blocks_throttle_0, '0', FFT_autocorrelation_0, '0']
- [blocks_throttle_0, '0', FFT_autocorrelation_0_0, '0']
- [blocks_throttle_0, '0', FFT_crosscorrelation_0_0, '0']
- [blocks_throttle_0, '0', FFT_crosscorrelation_0_0, '1']
- [tempest_fft_peak_fine_sampling_sync_0, '0', blocks_null_sink_0, '0']
- [tempest_fft_peak_fine_sampling_sync_0, '0', qtgui_time_sink_x_0_0, '0']
- [tempest_fft_peak_fine_sampling_sync_0, en, FFT_autocorrelation_0_0, en]
- [tempest_fft_peak_fine_sampling_sync_0, rate, tempest_message_to_var_0, port0]
- [tempest_fft_peak_fine_sampling_sync_0, ratio, tempest_fine_sampling_synchronization_0, ratio]
- [tempest_fine_sampling_synchronization_0, '0', blocks_complex_to_mag_0, '0']
- [tempest_fine_sampling_synchronization_0, '0', blocks_delay_0, '0']
- [tempest_infer_resolution_0, '0', qtgui_time_sink_x_0_0, '0']
- [tempest_normalize_flow_0, '0', blocks_float_to_short_0_0, '0']
- [uhd_usrp_source_0, '0', FFT_autocorrelation_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', tempest_fine_sampling_synchronization_0, '0']

metadata:
  file_format: 1
