<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>semi_automatic_tempest_example</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Hblank</value></param>
<param><key>value</key><value>Hsize-Hvisible</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Hcorrection</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label</key><value>Horizontal correction</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-20</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>20</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Hdisplay</value></param>
<param><key>value</key><value>Hsize</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Hsize</value></param>
<param><key>value</key><value>Hsizes[mode]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Hsizes</value></param>
<param><key>value</key><value>[832, 936, 800, 848, 832, 840, 832, 976, 992, 1008, 1008, 1024, 1024, 1056, 1040, 1056, 1048, 1072, 1312, 1264, 1344, 1328, 1312, 1376, 1392, 1408, 1520, 1600, 1552, 1568, 1680, 1680, 1800, 1728, 1728, 1760, 1688, 1688, 1728, 1760, 1776, 1800, 1880, 1896, 1896, 1912, 1928, 1904, 1936, 2144, 2160, 2176, 2192, 2144, 2176, 2096, 2176, 2160, 2160, 2160, 2160, 2160, 2208, 1840, 2240, 2256, 2448, 2456, 2528, 2560, 2576, 2608, 2592, 2624, 2600, 2640, 2048, 2044, 2800]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Hvisible</value></param>
<param><key>value</key><value>Hvisibles[mode]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Hvisibles</value></param>
<param><key>value</key><value>[640, 720, 640, 640, 640, 640, 640, 768, 768, 768, 768, 768, 800, 800, 800, 800, 800, 800, 1024, 1024, 1024, 1024, 1024, 1024, 1024, 1024, 1152, 1152, 1152, 1152, 1280, 1280, 1280, 1280, 1280, 1280, 1280, 1280, 1280, 1280, 1280, 1368, 1400, 1400, 1400, 1400, 1400, 1440, 1440, 1600, 1600, 1600, 1600, 1600, 1600, 1600, 1600, 1600, 1600, 1600, 1600, 1600, 1600, 1680, 1680, 1680, 1792, 1792, 1856, 1856, 1920, 1920, 1920, 1920, 1920, 1920, 1920, 1920, 2048]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Vblank</value></param>
<param><key>value</key><value>Vsize-Vvisible</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Vcorrection</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label</key><value>Vertical correction</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-20</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>20</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Vdisplay</value></param>
<param><key>value</key><value>768</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Vsize</value></param>
<param><key>value</key><value>Vsizes[mode]+Vcorrection</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Vsizes</value></param>
<param><key>value</key><value>[445, 446, 525, 509, 520, 500, 509, 597, 601, 602, 605, 611, 625, 628, 666, 625, 631, 636, 622, 817, 806, 806, 800, 808, 814, 823, 895, 900, 907, 915, 795, 828, 1000, 1002, 1011, 1017, 1066, 1066, 1072, 1085, 1097, 795, 1082, 1094, 1096, 1103, 1112, 932, 1087, 1035, 1044, 1050, 1059, 1060, 1069, 1070, 1075, 1250, 1250, 1250, 1250, 1250, 1271, 1080, 1089, 1087, 1394, 1417, 1439, 1500, 1125, 1126, 1242, 1253, 1500, 1500, 2434, 2434, 1589]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Vvisible</value></param>
<param><key>value</key><value>Vvisibles[mode]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Vvisibles</value></param>
<param><key>value</key><value>[400, 400, 480, 480, 480, 480, 480, 576, 576, 576, 576, 576, 600, 600, 600, 600, 600, 600, 600, 768, 768, 768, 768, 768, 768, 768, 864, 864, 864, 864, 768, 800, 960, 960, 960, 960, 1024, 1024, 1024, 1024, 1024, 768 , 1050, 1050, 1050, 1050, 1050, 900 , 1050, 1000, 1000, 1000, 1000, 1024, 1024, 1024, 1024, 1200, 1200, 1200, 1200, 1200, 1200, 1050, 1050, 1050, 1344, 1344, 1392, 1392, 1080, 1080, 1200, 1200, 1440, 1440, 2400, 2400, 1536] </value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>harmonic</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>4,1,1,1</value></param>
<param><key>label</key><value>Harmonic</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>horizontal_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>label</key><value>Horizontal offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>interpolatedHsize</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interpolatedHsize</value></param>
<param><key>value</key><value>int(Hsize/float(px_rate)*samp_rate)+Hcorrection</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>inverted</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>4,0,1,1</value></param>
<param><key>label0</key><value>Yes</value></param>
<param><key>label1</key><value>No</value></param>
<param><key>label</key><value>Inverted colors?</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>-1</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lines_offset</value></param>
<param><key>value</key><value>Vsize/2</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>label</key><value>Vertical offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>Vsize</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>mode</value></param>
<param><key>value</key><value>21</value></param>
<param><key>gui_hint</key><value>2,0,1,2</value></param>
<param><key>label</key><value>Display's resolution</value></param>
<param><key>labels</key><value>modes</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>range(len(modes))</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modes</value></param>
<param><key>value</key><value>["640x400 @ 85Hz", "720x400 @ 85Hz", "640x480 @ 60Hz", "640x480 @ 100Hz", "640x480 @ 72Hz", "640x480 @ 75Hz", "640x480 @ 85Hz", "768x576 @ 60 Hz", "768x576 @ 72 Hz", "768x576 @ 75 Hz", "768x576 @ 85 Hz", "768x576 @ 100 Hz", "800x600 @ 56Hz", "800x600 @ 60Hz", "800x600 @ 72Hz", "800x600 @ 75Hz", "800x600 @ 85Hz", "800x600 @ 100Hz", "1024x600 @ 60 Hz", "1024x768i @ 43Hz", "1024x768 @ 60Hz", "1024x768 @ 70Hz", "1024x768 @ 75Hz", "1024x768 @ 85Hz", "1024x768 @ 100Hz", "1024x768 @ 120Hz", "1152x864 @ 60Hz", "1152x864 @ 75Hz", "1152x864 @ 85Hz", "1152x864 @ 100Hz", "1280x768 @ 60 Hz", "1280x800 @ 60 Hz", "1280x960 @ 60Hz", "1280x960 @ 75Hz", "1280x960 @ 85Hz", "1280x960 @ 100Hz", "1280x1024 @ 60Hz", "1280x1024 @ 75Hz", "1280x1024 @ 85Hz", "1280x1024 @ 100Hz", "1280x1024 @ 120Hz", "1368x768 @ 60 Hz", "1400x1050 @ 60Hz", "1400x1050 @ 72 Hz", "1400x1050 @ 75 Hz", "1400x1050 @ 85 Hz", "1400x1050 @ 100 Hz", "1440x900 @ 60 Hz", "1440x1050 @ 60 Hz", "1600x1000 @ 60Hz", "1600x1000 @ 75Hz", "1600x1000 @ 85Hz", "1600x1000 @ 100Hz", "1600x1024 @ 60Hz", "1600x1024 @ 75Hz", "1600x1024 @ 76Hz", "1600x1024 @ 85Hz", "1600x1200 @ 60Hz", "1600x1200 @ 65Hz", "1600x1200 @ 70Hz", "1600x1200 @ 75Hz", "1600x1200 @ 85Hz", "1600x1200 @ 100 Hz", "1680x1050 @ 60Hz  reduced blanking ", "1680x1050 @ 60Hz  non-interlaced ", "1680x1050 @ 60 Hz", "1792x1344 @ 60Hz", "1792x1344 @ 75Hz", "1856x1392 @ 60Hz", "1856x1392 @ 75Hz", "1920x1080 @ 60Hz", "1920x1080 @ 75Hz", "1920x1200 @ 60Hz", "1920x1200 @ 75Hz", "1920x1440 @ 60Hz", "1920x1440 @ 75Hz", "1920x2400 @ 25Hz", "1920x2400 @ 30Hz", "2048x1536 @ 60Hz"]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>px_rate</value></param>
<param><key>value</key><value>Hsize*Vsize*refresh_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>refresh_rate</value></param>
<param><key>value</key><value>refresh_rates[mode]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>refresh_rates</value></param>
<param><key>value</key><value>[85, 85, 60, 100, 72, 75, 85, 60, 72, 75, 85, 100, 56, 60, 72, 75, 85, 100, 60, 43, 60, 70, 75, 85, 100, 120, 60, 75, 85, 100, 60, 60, 60, 75, 85, 100,  60,  75,  85,  100,  120, 60,  60,  72,  75,  85,  100 , 60,  60,  60,  75,  85,  100,  60,  75,  76,  85,  60,  65,  70,  75,  85,  100 ,  60,  60,  60,  60,  75,  60,  75,  60,  75,  60,  75,  60,  75,  25,  30,  60]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(40e6)</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>interpolatedHsize*lines_offset+horizontal_offset</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>grabacion_HDMI.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0_0</value></param>
<param><key>scale</key><value>inverted</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>inverted</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>tempest_fine_sampling_synchronization</key>
<param><key>id</key><value>tempest_fine_sampling_synchronization_0</value></param>
<param><key>correct_sampling</key><value>1</value></param>
<param><key>Htotal</key><value>interpolatedHsize</value></param>
<param><key>max_deviation</key><value>20.0/interpolatedHsize</value></param>
<param><key>update_proba</key><value>1e-2/(Hsize*Vsize)</value></param>
<param><key>Vtotal</key><value>Vsize</value></param>
</block>
<block>
<key>tempest_framing</key>
<param><key>id</key><value>tempest_framing_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>Hdisplay</key><value>Hdisplay</value></param>
<param><key>Htotal</key><value>interpolatedHsize</value></param>
<param><key>Vdisplay</key><value>Vdisplay</value></param>
<param><key>Vtotal</key><value>Vsize</value></param>
</block>
<block>
<key>tempest_normalize_flow</key>
<param><key>id</key><value>tempest_normalize_flow_0</value></param>
<param><key>alpha_avg</key><value>1e-2</value></param>
<param><key>max</key><value>245</value></param>
<param><key>min</key><value>10</value></param>
<param><key>update_proba</key><value>0.1</value></param>
<param><key>window</key><value>interpolatedHsize</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>px_rate*10*harmonic</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>50</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>video_sdl_sink</key>
<param><key>id</key><value>video_sdl_sink_0_0</value></param>
<param><key>comment</key><value>Enable this path when you are not sure what the 
resolution is and you want to try several ones 
on run-time. Then, enable the other path.</value></param>
<param><key>display_height</key><value>Vdisplay</value></param>
<param><key>display_width</key><value>Hdisplay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fps</key><value>0</value></param>
<param><key>height</key><value>Vdisplay</value></param>
<param><key>type</key><value>short</value></param>
<param><key>width</key><value>Hdisplay</value></param>
</block>
<block>
<key>video_sdl_sink</key>
<param><key>id</key><value>video_sdl_sink_0_0_0</value></param>
<param><key>comment</key><value>Enable this path when you are sure what the 
resolution is (and defaut to those values on 
the chooser).</value></param>
<param><key>display_height</key><value>Vsize</value></param>
<param><key>display_width</key><value>Hsize</value></param>
<param><key>fps</key><value>0</value></param>
<param><key>height</key><value>Vsize</value></param>
<param><key>type</key><value>short</value></param>
<param><key>width</key><value>interpolatedHsize</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>tempest_normalize_flow_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0_0</source_block_id><sink_block_id>video_sdl_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0_0_0</source_block_id><sink_block_id>video_sdl_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>tempest_fine_sampling_synchronization_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tempest_fine_sampling_synchronization_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tempest_framing_0</source_block_id><sink_block_id>blocks_float_to_short_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tempest_normalize_flow_0</source_block_id><sink_block_id>blocks_float_to_short_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tempest_normalize_flow_0</source_block_id><sink_block_id>tempest_framing_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>tempest_fine_sampling_synchronization_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
