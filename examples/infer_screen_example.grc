options:
  parameters:
    generate_options: qt_gui
    id: manual_tempest_example
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: DroppedFrames
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: Hsize
  id: variable_qtgui_range
  parameters:
    label: Horizontal resolution (total)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(4096*1.5)
    value: '2200'
    widget: counter
  states: {}
- name: Vsize
  id: variable_qtgui_range
  parameters:
    label: Vertical resolution (total)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: int(2160*1.5)
    value: '1125'
    widget: counter
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: 2**20
  states: {}
- name: harmonic
  id: variable_qtgui_range
  parameters:
    label: Harmonic
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: px_rate
  id: variable
  parameters:
    value: Hsize*Vsize*refresh_rate
  states: {}
- name: refresh_rate
  id: variable_qtgui_range
  parameters:
    label: refr
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(19.98e6)
  states: {}
- name: FFT_autocorrelation_0_0
  id: FFT_autocorrelation
  parameters:
    alpha: '1.0'
    fft_size: int(fft_size)
  states: {}
- name: Keep_1_in_N_Frames_0
  id: Keep_1_in_N_Frames
  parameters:
    fac_decimation: DroppedFrames
    fft_size: fft_size
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/felipe/gnuradio/git/grabaciones_local/test2_19980KHz_1920_1080.dat
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: int(fft_size/2)
    srate: samp_rate
    tr_tag: '"peak_1"'
    type: float
    update_time: '1.0'
  states: {}
- name: tempest_infer_screen_resolution_0
  id: tempest_infer_screen_resolution
  parameters:
    automatic_mode: 'True'
    fft_size: int(fft_size)
    refresh_rate: refresh_rate
    sample_rate: samp_rate
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: px_rate*harmonic
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '"recv_frame_size= 65536, num_recv_frames=128"'
    gain0: '50'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [FFT_autocorrelation_0_0, '0', tempest_infer_screen_resolution_0, '0']
- [Keep_1_in_N_Frames_0, '0', FFT_autocorrelation_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', Keep_1_in_N_Frames_0, '0']
- [tempest_infer_screen_resolution_0, '0', qtgui_time_sink_x_1_0, '0']
- [uhd_usrp_source_0, '0', Keep_1_in_N_Frames_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
