options:
  parameters:
    generate_options: qt_gui
    id: example_ecualization
    output_language: python
    title: example_ecualization
  states: {}

blocks:
- name: Hsize
  id: variable
  parameters:
    value: '2200'
  states: {}
- name: Hvisible
  id: variable
  parameters:
    value: '1920'
  states: {}
- name: Vsize
  id: variable
  parameters:
    value: '1125'
  states: {}
- name: Vvisible
  id: variable
  parameters:
    value: '1080'
  states: {}
- name: decim
  id: variable
  parameters:
    value: inter
  states: {}
- name: filtro_ecualizador_1st
  id: variable
  parameters:
    value: |-
      [-3.11363682e-06+6.75278918e-06j,  2.23797433e-05+3.63850305e-04j,
              1.24424796e-04+2.07552626e-03j,  9.13369821e-05+1.23922328e-03j,
              9.17470541e-06-1.27599772e-03j, -1.89672336e-04-7.66449364e-03j,
             -6.04326364e-04-2.07456042e-02j, -1.03016890e-03-4.52780337e-02j,
             -2.24322298e-03-7.65338416e-02j, -2.59317061e-03-1.35562197e-01j,
             -5.05937146e-03-1.88184719e-01j, -4.40754770e-03-2.95364441e-01j,
             -8.83183526e-03-3.55251606e-01j, -5.10069889e-03-5.21066895e-01j,
             -1.41464771e-02-5.38323401e-01j,  2.42260390e-03-8.16748190e-01j,
              4.49687679e-02+2.68517170e-01j, -1.78853630e-02+7.82072975e-01j,
             -4.44448737e-03+4.96178030e-01j, -1.02738240e-02+4.81143615e-01j,
             -4.81582961e-03+3.17597516e-01j, -6.18209100e-03+2.63011491e-01j,
             -3.16653758e-03+1.61327366e-01j, -3.01959070e-03+1.15054664e-01j,
             -1.44674044e-03+6.17245262e-02j, -9.99648902e-04+3.55652006e-02j,
             -3.99929733e-04+1.49286935e-02j, -9.70523497e-05+4.64566966e-03j,
              4.45207677e-05+1.15474691e-04j,  1.16728796e-04-1.83264974e-03j,
              9.57920774e-05-1.59212307e-03j, -3.78999089e-06+4.47966583e-05j]
  states: {}
- name: fine_freq
  id: variable_qtgui_range
  parameters:
    label: Fine frequency correction
    orient: Qt.Horizontal
    start: '-2*usrp_rate'
    step: '3'
    stop: 2*usrp_rate
    value: '0'
  states: {}
- name: harmonic
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Harmonic
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: horizontal_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Horizontal offset
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: interpolatedHsize
    value: '0'
  states: {}
- name: inter
  id: variable
  parameters:
    value: '10'
  states: {}
- name: interpolatedHsize
  id: variable
  parameters:
    value: int(Hsize/float(px_rate)*usrp_rate)
  states: {}
- name: inverted
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,1,1,1
    label: Inverted colors?
    label0: 'Yes'
    label1: 'No'
    num_opts: '2'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: real
    value: '-1'
    widget: radio_buttons
  states: {}
- name: lines_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: Vertical offset
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Vsize
    value: int(Vsize/2)
  states: {}
- name: px_rate
  id: variable
  parameters:
    value: Hsize*Vsize*refresh_rate
  states: {}
- name: rectangular_pulse
  id: variable
  parameters:
    value: '[0.7/255]*inter'
  states: {}
- name: refresh_rate
  id: variable
  parameters:
    value: '60'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: int(19.98e6)
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-fine_freq'
    offset: '0'
    phase: '0'
    samp_rate: usrp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: interpolatedHsize*lines_offset+horizontal_offset
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: interpolatedHsize
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/victoria/GNUfiles/grabaciones/test2_19980KHz_1920_1080.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: inverted
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: usrp_rate
    type: complex
  states: {}
- name: interp_fir_filter_xxx_1
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: filtro_ecualizador_1st
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: usrp_rate
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.001'
    type: complex
  states: {}
- name: tempest_fine_sampling_synchronization_0
  id: tempest_fine_sampling_synchronization
  parameters:
    Htotal: interpolatedHsize
    Vtotal: Vsize
    correct_sampling: '1'
    max_deviation: 10.0/interpolatedHsize
    update_proba: 10e-2/(Hsize*Vsize)
  states: {state: bypassed}
- name: tempest_fine_sampling_synchronization_0_0
  id: tempest_fine_sampling_synchronization
  parameters:
    Htotal: interpolatedHsize
    Vtotal: Vsize
    correct_sampling: '1'
    max_deviation: 10.0/interpolatedHsize
    update_proba: 10e-2/(Hsize*Vsize)
  states: {}
- name: tempest_normalize_flow_0
  id: tempest_normalize_flow
  parameters:
    alpha_avg: '1e-2'
    max: '245'
    min: '10'
    update_proba: '0.1'
    window: interpolatedHsize
  states: {}
- name: video_sdl_sink_0_0_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Enable this path when you are sure what the 
      resolution is (and defaut to those values on 
      the chooser).
    display_height: '720'
    display_width: '1280'
    fps: '0'
    height: Vsize
    type: short
    width: interpolatedHsize
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', tempest_normalize_flow_0, '0']
- [blocks_complex_to_real_0, '0', tempest_normalize_flow_0, '0']
- [blocks_delay_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_delay_0, '0', blocks_complex_to_real_0, '0']
- [blocks_delay_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_short_0, '0', video_sdl_sink_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_xx_0_0, '0', tempest_fine_sampling_synchronization_0, '0']
- [blocks_throttle_0, '0', blocks_delay_1, '0']
- [blocks_throttle_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_throttle_0, '0', tempest_fine_sampling_synchronization_0_0, '0']
- [interp_fir_filter_xxx_1, '0', blocks_multiply_xx_0_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_complex_to_arg_0, '0']
- [tempest_fine_sampling_synchronization_0, '0', blocks_delay_0, '0']
- [tempest_fine_sampling_synchronization_0_0, '0', interp_fir_filter_xxx_1, '0']
- [tempest_normalize_flow_0, '0', blocks_float_to_short_0, '0']

metadata:
  file_format: 1
