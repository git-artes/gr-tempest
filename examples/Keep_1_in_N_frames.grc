options:
  parameters:
    author: tempest
    category: '[Tempest]'
    generate_options: hb
    id: Keep_1_in_N_Frames
    output_language: python
    title: Keep_1_in_N_Frames
  states: {}

blocks:
- name: fac_size
  id: variable
  parameters:
    value: fft_size
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: fac_decimation
    type: complex
    vlen: fac_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fac_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fac_size
    type: complex
  states: {}
- name: fac_decimation
  id: parameter
  parameters:
    label: N Frames
    type: intx
    value: '10'
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: Frame Size
    type: intx
    value: int(4096*512)
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [blocks_keep_one_in_n_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_vector_to_stream_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-215-g9a698313
